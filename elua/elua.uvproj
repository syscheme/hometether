# Keil uVision project elua.uvproj, settings and files
target elua-stm32 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: elua
  c flags: Optim=1 wLevel=2
  c define: LUA_CROSS_COMPILER,CON_UART_ID=0,CON_UART_SPEED=115200,CON_TIMER_ID=0
  c include: .\src\platform;.\src\platform\stm32;.\src\platform\stm32\FWLib\library\inc;.\inc;.\src\lua
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group lua
    ./src/lua/: lapi.c lauxlib.c lbaselib.c lcode.c ldblib.c ldebug.c ldo.c legc.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c lobject.c lopcodes.c loslib.c lparser.c lrotable.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lua.c luac.c lundump.c lvm.c lzio.c print.c ldump.c
  group FWLib
    ./src/platform/stm32/FWLib/library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group platform
    ./src/platform/stm32/: core_cm3.c platform.c stm32f10x_it.c system_stm32f10x.c stm32f10x_hd.s
  group elua
    ./src/: main.c common.c
  group module
    ./src/modules/: elua.c adc.c bit.c bitarray.c can.c cpu.c i2c.c lpack.c luarpc.c pd.c pio.c net.c uart.c pwm.c spi.c term.c tmr.c
