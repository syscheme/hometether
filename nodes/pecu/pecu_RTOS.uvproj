# Keil uVision project pecu_RTOS.uvproj, settings and files
target ebey_flash (ARM-ADS)
  device: STM32F105VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ebey_pecu +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: RVDS_ARMCM3_LM3S102,USE_STDPERIPH_DRIVER, STM32F10X_HD,USE_STM3210B_EVAL,FreeRTOS
  c include: .;..\..\stm32\FWlib\inc;..\..\stm32\common;..\..\Common;..\..\Common\stm32;..\..\FreeRTOSV8.1.2\FreeRTOS\Demo\Common\include;..\..\FreeRTOSV8.1.2\FreeRTOS\Source\include;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System
    ../../stm32/FWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_pwr.c
  group FreeRTOS files
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/: tasks.c list.c queue.c
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../common/stm32/: FreeRTOS_IRQ.c FreeRTOS.s
    ./: FreeRTOSConfig.h
  group App
    ./: bsp_pecu.c task_pecu.c main_rtos.c pecu.c isr_pecu.c
  group Dev
    ../../common/: 1wire.c ds18b20.c htcomm.c pbuf.c htddl.c htcluster.c textmsg.c esp8266.c
    ../../common/stm32/: delay.c io.c
