# Keil uVision project pecu.uvproj, settings and files
target secu (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: secu +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL, WITH_UCOSII,MAX_PENDMSGS=5
  c include: .;..\..\stm32\FWlib\inc;..\..\uCOS-II;..\..\stm32\common;.\bsp_v1.0;..\..\CanFestival-3\include;..\..\CanFestival-3\stm32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry ResetHndlr
  group app
    ../../stm32/common/: ds18b20.c 1wire.c common.c pulses.c enc28j60.c ip_arp_udp_tcp.c
    ../: htod.c htcan.c bsp_dq.c
    ./: init.s state_secu.c task_secu.c bsp_secu.c htcan_secu.c int_secu.c gw_secu.c
  group uc-cpu
    ../../uCOS-II/uc-cpu/ARM-Cortex-M3/: cpu_a.asm cpu_c.c
  group uCOS-II/Source
    ../../uCOS-II/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/Port
    ../../uCOS-II/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uc-lib
    ../../uCOS-II/uc-lib/: lib_mem.c lib_str.c
    ../../uCOS-II/uc-lib/Ports/: lib_mem_a.asm
  group doc
    ./: readme.txt
  group startup
    ../../stm32/common/: cortexm3_macro.s
    ./: startup_ucosii_hd.s
  group FWLib
    ../../stm32/FWlib/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
