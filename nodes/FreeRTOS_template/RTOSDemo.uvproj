# Keil uVision project RTOSDemo.uvproj, settings and files
target flash (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOSDemo
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102
  c include: .;..\..\stm32\FWLib\inc;..\..\FreeRTOSV8.1.2\FreeRTOS\Demo\Common\include;..\..\FreeRTOSV8.1.2\FreeRTOS\Source\include;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ../FreeRTOS_template/: STM32F10x.s
    ../../stm32/FWLib/src/: cortexm3_macro_rvds.s stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c misc.c
  group Demo Files
    ../FreeRTOS_template/ParTest/: ParTest.c
    ../FreeRTOS_template/: timertest.c main.c
    ../../FreeRTOSV8.1.2/FreeRTOS/Demo/Common/Minimal/: semtest.c BlockQ.c blocktim.c comtest.c death.c flash.c integer.c PollQ.c
    ../FreeRTOS_template/serial/: serial.c
  group FreeRTOS files
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/: tasks.c list.c queue.c
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/portable/MemMang/: heap_2.c
