# Keil uVision project camcar.uvproj, settings and files
target IAP15W205S (MCS-51)
  device: STC15F408AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: camcar +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 camcar.c delay.c USART1.C
