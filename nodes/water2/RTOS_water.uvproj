# Keil uVision project RTOS_water.uvproj, settings and files
target flash (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOS_water
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102,HSE_FREQ_8MHz,FreeRTOS,STM32F10X_MD
  c include: .;..\..\stm32\FWLib\inc;..\..\common;..\..\common\stm32;..\..\FreeRTOSV8.1.2\FreeRTOS\Demo\Common\include;..\..\FreeRTOSV8.1.2\FreeRTOS\Source\include;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ../../stm32/FWLib/src/: cortexm3_macro_rvds.s stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c misc.c
  group Demo Files
    ../../FreeRTOSV8.1.2/FreeRTOS/Demo/Common/Minimal/: death.c
  group FreeRTOS files
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/: tasks.c list.c queue.c
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../common/stm32/: FreeRTOS_IRQ.c FreeRTOS.s
  group app
    ./: rtos_main.c bsp_water2.c isr_water2.c task_water2.c water2.c
  group dev
    ../../common/: 1wire.c ds18b20.c pulses.c pulses_cap.c si4432.c htcluster.c htcomm.c htddl.c pbuf.c textmsg.c
    ../../common/stm32/: io.c delay.c
