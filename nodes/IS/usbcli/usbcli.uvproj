# Keil uVision project usbcli.uvproj, settings and files
target usb_flash (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usbcli +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL,USB_ENABLED
  c include: .;..\..\..\stm32\FWLib\inc;..\..\..\uCOS-II;..\..\..\stm32\common;..\bsp_v1.0;..\..\..\stm32\usblib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\bsp_v1.0\STM32_Flash.scat
  link misc: --entry ResetHndlr
  group app
    ../: int_is.c bsp_ISv2.c
    ./: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c tasks_usbcli.c
    ../../../stm32/common/: 1wire.c common.c ds18b20.c nrf24l01.c pulses.c
  group usblib
    ../../../stm32/usblib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group FWlib
    ../../../stm32/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group startup
    ../: vectors.s
    ../bsp_v1.0/: init.s
    ../../../stm32/common/: cortexm3_macro.s
  group uc-cpu
    ../../../uCOS-II/uc-cpu/ARM-Cortex-M3/: cpu_a.asm cpu_c.c
  group uCOS-II/Source
    ../../../uCOS-II/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/Port
    ../../../uCOS-II/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uc-lib
    ../../../uCOS-II/uc-lib/: lib_mem.c lib_str.c
    ../../../uCOS-II/uc-lib/Ports/: lib_mem_a.asm
