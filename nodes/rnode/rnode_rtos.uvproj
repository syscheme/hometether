# Keil uVision project rnode_rtos.uvproj, settings and files
target rtos_flash (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rnode +hex
  c flags: Optim=2 oTime=1 OneElfS=1 wLevel=2
  c define: RVDS_ARMCM3_LM3S102,USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_STM3210B_EVAL,STM32F103_32MHz,FreeRTOS
  c include: .;..\..\stm32\FWlib\inc;..\..\stm32\common;..\..\Common;..\..\Common\stm32;..\..\FreeRTOSV8.1.2\FreeRTOS\Demo\Common\include;..\..\FreeRTOSV8.1.2\FreeRTOS\Source\include;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
  group app
    ./: bsp_rnode.c isr_rnode.c main_rnode.c task_rnode.c
  group doc
    ./: readme.txt
  group startup
    ../../uCOS-II/startup/: cortexm3_macro.s
  group FWLib
    ../../stm32/FWlib/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../FreeRTOSV8.1.2/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../common/stm32/: FreeRTOS_IRQ.c FreeRTOS.s
  group dev
    ../../common/: si4432.c pbuf.c 1wire.c ds18b20.c pulses.c pulses_cap.c enc28j60.c ip_arp_udp_tcp.c htcomm.c usart.c nrf24l01.c htcluster.c htddl.c
    ../../common/stm32/: io.c delay.c
target rtos_ram (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rnode_ram +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL,RAM_DEBUG,STM32F103_32MHz
  c include: .;..\..\stm32\FWlib\inc;..\..\uCOS-II;..\..\stm32\common;.\bsp_v1.0;..\..\common;..\..\common\stm32
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  scatter file: .\STM32_RAM.scat
  link misc: --entry ResetHndlr
