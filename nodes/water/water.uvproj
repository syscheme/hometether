# Keil uVision project water.uvproj, settings and files
target STC89C52RD (MCS-51)
  device: SST89V564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: wcnode +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: STC_CLASS=89
  c include: .,..\..\c51
  group Source Group 1
    ./: wcnode.c
    ../../c51/: utils.c STARTUP.A51 delay_AT89.c
