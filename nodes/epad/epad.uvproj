# Keil uVision project epad.uvproj, settings and files
target STC89C52RD (MCS-51)
  device: SST89V564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: epad +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .,..\..\c51
  group app
    ../../c51/: utils.c STARTUP.A51
    ./: epad.c
