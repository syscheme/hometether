# Keil uVision project stm32_RJ45_4x2.uvproj, settings and files
target stm32_RJ45_4x2 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_RJ45_4x2 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL, WITH_UCOSII,MAX_PENDMSGS=5
  c include: .;..\..\stm32\FWlib\inc;..\..\common;..\..\common\stm32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry ResetHndlr
  group app
    ../../common/: ds18b20.c 1wire.c pulses.c enc28j60.c
    D:/workspace.t3600/iotprojs/ht/common/stm32/: io.c
    ./: bsp.c
    D:/workspace.t3600/iotprojs/ht/nodes/stm32_RJ45_4x2/: ints.c main.c
  group doc
    ./: readme.txt
  group startup
    ./: init.s
    D:/workspace.t3600/iotprojs/ht/stm32/common/: cortexm3_macro.s
  group FWLib
    ../../stm32/FWlib/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
