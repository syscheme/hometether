# Keil uVision project stm_RJ45_4x2.uvproj, settings and files
target flash (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rnode +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_STM3210B_EVAL,HSE_FREQ_8MHz
  c include: .;..;..\..\common;..\..\common\stm32;..\..\stm32\FWlib\inc;..\..\stm32\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\stm32\STM32_Flash.scat
  link misc: --entry ResetHndlr
  group app
    ./: system_stm32f10x.c isr_water2.c bsp_water2.c main0.c water2.c
  group doc
    ./: readme.txt
  group startup
    ../../uCOS-II/startup/: cortexm3_macro.s
  group FWLib
    ../../stm32/FWlib/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group common
    ./: vectors.s init.s
    ../../common/: si4432.c pbuf.c htcomm.c 1wire.c ds18b20.c pulses.c pulses_cap.c
    ../../common/stm32/: io.c delay.c
target ram (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rnode_ram +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL,RAM_DEBUG,STM32F103_32MHz
  c include: .;..\..\stm32\FWlib\inc;..\..\uCOS-II;..\..\stm32\common;.\bsp_v1.0;..\..\common;..\..\common\stm32
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  scatter file: .\STM32_RAM.scat
  link misc: --entry ResetHndlr
