# Keil uVision project heaterpwr.uvproj, settings and files
target STC15F204EA (MCS-51)
  device: STC15F204EA STC
  cpu: IRAM(0-0xFF) IROM(0-0xFF8) CLOCK(35000000)
  output: heaterpwr +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\c51
  group src
    ./: STARTUP.A51 heaterpwr.c camcar.c
    ../../c51/: utils.c
