# Repository syscheme/hometether (continued)

## KiCad design kicad/robot/r1/r4_good1.kicad_pcb

Parts:
C1, C2, C4, C5: 10P
C3, C8, C10, C11: 104
C6, C9: 47u
C7: 10u
D3, D4: LED
IC1: REG1117; burr-brown-3-SOT223
J1: RJ45
J2: MINI-USB-5P; con-cypressindustries-32005-201
K1, K2: CONN_3
P1: SWD
P2: SI4432
P3: nRF24L01
P4: CONN_2mm
P5, P7, P8: CONN_10X2
P6: CONN_8
P9: CONN_1
Q1: S8550
R3, R4: 4K7
R5, R6, R9, R12: 10K
R8: 1K5
R17, R18: 1K
R26, R27: 22
U1: STM32F10XC; STM32F10xC-TQFP48
VR1: LUMIN
X1: 8M
X2: 32.768K

Connections:
/A1: P4.1, P5.1, U1.11
/A2: P4.3, P5.3, U1.12
/A3: P4.5, P5.5, U1.13
/A9: P4.24, P5.20, R4.2, U1.30
/A10: P4.22, P5.18, R3.2, U1.31
/A15: P4.23, U1.38
/ADC: C10.1, R12.1, U1.10, VR1.2
/B0: P3.8, P4.7, P5.7, U1.18
/B1: P2.10 (nIRQ), P4.9, P5.9, U1.19
/B6: P4.16, P5.14, U1.42
/B7: P4.14, P5.12, U1.43
/B8: P4.10, P5.10, U1.45
/B9: P4.8, P5.8, U1.46
/B10: P2.11 (SDN), P3.9, P4.11, P5.11, U1.21
/B11: P3.3, P4.13, P5.13, U1.22
/B12: P4.15, P5.16, U1.25
/B13: P4.17, P5.15, U1.26
/B14: P4.19, P5.17, U1.27
/B15: P4.21, P5.19, U1.28
/LED0: R17.2, U1.40
/LED1: R18.2, U1.41
/RF2SEL: P2.9 (nSEL), P3.10, U1.29
/RFSCK: P2.8 (SCLK), P3.5, U1.15
/RFSDI: P2.7 (SDI), P3.6, U1.17
/RFSDO: P2.6 (SDO), P3.7, U1.16
/RFnSEL: P3.4, U1.14
/TCK: P1.3, R5.2, U1.37
/TMS: P1.2, R6.2, U1.34
/USBDM: R27.1, U1.32
/USBDP: R26.1, U1.33
/USBI: Q1.1 (B), R9.1, U1.39
/nRST: C3.1, P9.1, U1.7
GND: C1.2, C2.1, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, IC1.1 (GND), J2.5, K1.3, K2.1, P1.4, P2.1 (GND), P2.12 (GND), P3.1, P4.4, P4.12, P4.20, P5.4, R12.2, U1.8, U1.23, U1.35, U1.47
unnamed: J2.2, R27.2
unnamed: K1.2 (PM), U1.44
unnamed: C2.2, U1.6, X1.2
unnamed: C5.2, U1.4, X2.1
unnamed: J1.6, P6.6
unnamed: J1.7, P6.7
unnamed: J1.8, P6.8
unnamed: J1.1, P6.1
unnamed: J1.2, P6.2
unnamed: J1.3, P6.3
unnamed: J1.4, P6.4
unnamed: J1.5, P6.5
unnamed: K2.2 (PM), U1.20
unnamed: J2.3, R8.1, R26.2
unnamed: D4.2 (K), R18.1
unnamed: D3.2 (K), R17.1
unnamed: C4.1, U1.3, X2.2
unnamed: C1.1, U1.5, X1.1
unnamed: Q1.3 (C), R8.2
unnamed: P7.1, P8.1
unnamed: P7.2, P8.2
unnamed: P7.3, P8.3
unnamed: P7.4, P8.4
unnamed: P7.5, P8.5
unnamed: P7.6, P8.6
unnamed: P7.7, P8.7
unnamed: P7.8, P8.8
unnamed: P7.9, P8.9
unnamed: P7.10, P8.10
unnamed: P7.11, P8.11
unnamed: P7.12, P8.12
unnamed: P7.13, P8.13
unnamed: P7.14, P8.14
unnamed: P7.15, P8.15
unnamed: P7.16, P8.16
unnamed: P7.17, P8.17
unnamed: P7.18, P8.18
unnamed: P7.19, P8.19
unnamed: P7.20, P8.20

Parts:
C1, C2, C4, C5: 10P
C3, C8, C10, C11: 104
C6, C9: 47u
C7: 10u
D1: 1N4148
D3, D4: LED
IC1: REG1117; burr-brown-3-SOT223
J1: RJ45
J2: MINI-USB-5P; con-cypressindustries-32005-201
K1, K2: CONN_3
P1: SWD
P2: SI4432
P3: nRF24L01
P4: CONN_2mm
P5, P7, P8: CONN_10X2
P6: CONN_8
P9: CONN_1
Q1: S8550
R3, R4: 4K7
R5, R6, R9, R12: 10K
R8: 1K5
R17, R18: 1K
R26, R27: 22
U1: STM32F10XC; STM32F10xC-TQFP48
VR1: LUMIN
X1: 8M
X2: 32.768K

Connections:
/A1: P4.1, P5.1, U1.11
/A2: P4.3, P5.3, U1.12
/A3: P4.5, P5.5, U1.13
/A9: P4.24, P5.20, R4.2, U1.30
/A10: P4.22, P5.18, R3.2, U1.31
/A15: P4.23, U1.38
/ADC: C10.1, R12.1, U1.10, VR1.2
/B0: P3.8, P4.7, P5.7, U1.18
/B1: P2.10 (nIRQ), P4.9, P5.9, U1.19
/B6: P4.16, P5.14, U1.42
/B7: P4.14, P5.12, U1.43
/B8: P4.10, P5.10, U1.45
/B9: P4.8, P5.8, U1.46
/B10: P2.11 (SDN), P3.9, P4.11, P5.11, U1.21
/B11: P3.3, P4.13, P5.13, U1.22
/B12: P4.15, P5.16, U1.25
/B13: P4.17, P5.15, U1.26
/B14: P4.19, P5.17, U1.27
/B15: P4.21, P5.19, U1.28
/LED0: R17.2, U1.40
/LED1: R18.2, U1.41
/RF2SEL: P2.9 (nSEL), P3.10, U1.29
/RFSCK: P2.8 (SCLK), P3.5, U1.15
/RFSDI: P2.7 (SDI), P3.6, U1.17
/RFSDO: P2.6 (SDO), P3.7, U1.16
/RFnSEL: P3.4, U1.14
/TCK: P1.3, R5.2, U1.37
/TMS: P1.2, R6.2, U1.34
/USBDM: R27.1, U1.32
/USBDP: R26.1, U1.33
/USBI: Q1.1 (B), R9.1, U1.39
/nRST: C3.1, P9.1, U1.7
GND: C1.2, C2.1, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, IC1.1 (GND), J2.5, K1.3, K2.1, P1.4, P2.1 (GND), P2.12 (GND), P3.1, P4.4, P4.12, P4.20, P5.4, R12.2, U1.8, U1.23, U1.35, U1.47
unnamed: J2.2, R27.2
unnamed: K1.2 (PM), U1.44
unnamed: C2.2, U1.6, X1.2
unnamed: C5.2, U1.4, X2.1
unnamed: J1.6, P6.6
unnamed: J1.7, P6.7
unnamed: J1.8, P6.8
unnamed: J1.1, P6.1
unnamed: J1.2, P6.2
unnamed: J1.3, P6.3
unnamed: J1.4, P6.4
unnamed: J1.5, P6.5
unnamed: K2.2 (PM), U1.20
unnamed: J2.3, R8.1, R26.2
unnamed: D4.2 (K), R18.1
unnamed: D3.2 (K), R17.1
unnamed: C4.1, U1.3, X2.2
unnamed: C1.1, U1.5, X1.1
unnamed: Q1.3 (C), R8.2
unnamed: P7.1, P8.1
unnamed: P7.2, P8.2
unnamed: P7.3, P8.3
unnamed: P7.4, P8.4
unnamed: P7.5, P8.5
unnamed: P7.6, P8.6
unnamed: P7.7, P8.7
unnamed: P7.8, P8.8
unnamed: P7.9, P8.9
unnamed: P7.10, P8.10
unnamed: P7.11, P8.11
unnamed: P7.12, P8.12
unnamed: P7.13, P8.13
unnamed: P7.14, P8.14
unnamed: P7.15, P8.15
unnamed: P7.16, P8.16
unnamed: P7.17, P8.17
unnamed: P7.18, P8.18
unnamed: P7.19, P8.19
unnamed: P7.20, P8.20

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
Board: 2 copper layers, 48.4 x 46.2 mm, 44 parts (22 on the bottom side), 47 nets.

Other parts of the board:
>VALUE: >NAME; maxim-10-SO20L
P?: ROW10_2mm
P?#2: ROW10_2mmM1

## Commit log

2018-09-04 from svn
2023-04-01 init CircuitBreaker
2023-04-01 pwr and up/down link
2023-04-01 sch-erc checked
2023-04-02 edge-cut of pcb
2023-04-05 circuit breaker pcb layout
2023-04-05 ccb pcb rev
2023-04-06 footprints applied
2023-04-06 net mapped to pcb
2023-04-06 pcb rev
2023-04-08 pcb all connected
2023-04-16 pcb err check
2023-04-17 silklayers review
2023-04-17 elimited 1.27trackwidth
2023-04-17 order1870547450283934879 on 20230417
2023-04-21 init analog-switch
2023-04-22 proj settings
2023-04-22 make analog-sw to DIP-40
2023-04-24 corrected stc tssop20
2023-05-02 cm104 add jack
