# Repository syscheme/hometether

## KiCad design kicad/CircuitBreaker/CircuitBreaker.kicad_pcb

Parts:
C1, C2, C3, C4: 1uF; C_0603_1608Metric
C5, C6, C10: 0.1uF; C_0603_1608Metric
C7: 22uF; C_0805_2012Metric
C8: 220uF; CP_Elec_6.3x5.2
C9: 100uF; CP_Elec_6.3x5.2
D1: led+; LED_0603_1608Metric
D2: led; LED_0603_1608Metric
J1, J2, J3, J4: PH2.54; PinHeader_1x02_P2.54mm_Vertical
J5: downlink; PinHeader_1x04_P2.00mm_Vertical
J6: uplink; PinSocket_1x04_P2.00mm_Vertical
J7: PWN-In-5v; PinHeader_1x02_P2.54mm_Vertical
JP1, JP2: bus-type; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP3, JP4: I2C; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP5, JP6: dbg-sel; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R1, R2, R3, R7: 120; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R4, R5, R6, R8: 240; R_0805_2012Metric
R9, R10, R11, R12: 47K; R_0603_1608Metric
R13, R14, R15, R17, R20, R21, R22, R23, R24: 10K; R_0603_1608Metric
R16: 300; R_0805_2012Metric
R18, R19: 22; R_0603_1608Metric
R25: 5vUP; R_0805_2012Metric
R26, R27: 4K7; R_0603_1608Metric
SW1: usbIAP; SW_DIP_SPSTx01_Slide_6.7x4.1mm_W6.73mm_P2.54mm_LowProfile_J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
T1, T2, T3, T4: CT104D; Transformer_CT204D
U1: LM324; SOP-14_3.9x9.9mm_P1.27mm
U2: STC8H8K64U; TSSOP-20_4.4x6.5mm_P0.65mm
U3: AP1117-33; SOT-223-3_TabPin2
U4: ESP-12E

Connections:
+3V3: C9.1, C10.1, J6.1, R13.1, R14.1, R20.1, R21.1, R22.2, R23.2, R24.2, R25.2, U3.2 (VO), U4.8 (VCC)
+5V: C6.1, C7.1, C8.1, D1.2 (A), D2.2 (A), J5.1, J7.1, R15.1, R25.1, U1.4 (V+), U2.8 (Vcc), U2.9 (ADC_Vref), U3.3 (VI)
/P3.0: R18.1, U2.11 (P3.0/RxD/ADC8)
/P3.1: R19.1, U2.12 (P3.1/TxD/ADC9)
/RXD_DWN: J5.3, JP2.2 (C), R14.2
/RXD_UP: J6.2, JP3.2 (B), JP6.1 (A), R18.2, R20.2
/TXD_DWN: J5.2, JP1.2 (C), R13.2
/TXD_UP: J6.3, JP4.2 (B), JP5.1 (A), R19.2, R21.2
ADC0: C1.1, R1.1, R4.1, R9.1, U1.1, U2.5 (P1.3/ADC3)
ADC1: C2.1, R2.1, R5.1, R10.1, U1.7, U2.14 (P3.3/ADC11/SDA_4)
ADC2: C3.1, R3.1, R6.1, R11.1, U1.8, U2.15 (P3.4/ADC12)
ADC3: C4.1, R7.1, R8.1, R12.1, U1.14, U2.16 (P3.5/ADC13)
DRXD: JP2.1 (A), U2.19 (P1.0/ADC0/RxD2)
DTXD: JP1.1 (A), U2.20 (P1.1/ADC1/TxD2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J1.2, J2.2, J3.2, J4.2, J5.4, J6.4, J7.2, R9.2, R10.2, R11.2, R12.2, R17.1, SW1.1, T1.3 (SA), T2.3 (SA), T3.3 (SA), T4.3 (SA), U1.3 (+), U1.5 (+), U1.10 (+), U1.11 (V-), U1.12 (+), U2.10 (GND/AGND), U3.1 (GND), U4.15 (GND)
unnamed: C5.1, U2.6 (TCap)
unnamed: D1.1 (K), R26.2
unnamed: D2.1 (K), R27.2
unnamed: J1.1, R1.2, R4.2, T1.4 (SB), U1.2 (-)
unnamed: J2.1, R2.2, R5.2, T2.4 (SB), U1.6 (-)
unnamed: J3.1, R3.2, R6.2, T3.4 (SB), U1.9 (-)
unnamed: J4.1, R7.2, R8.2, T4.4 (SB), U1.13 (-)
unnamed: JP5.2 (B), U4.21 (GPIO3/RXD)
unnamed: JP6.2 (B), U4.22 (GPIO1/TXD)
unnamed: R15.2, R16.1, U2.13 (P3.2/ADC10/SCL_4)
unnamed: R16.2, SW1.2
unnamed: R17.2, U4.16 (GPIO15)
unnamed: R22.1, U4.18 (GPIO0)
unnamed: R23.1, U4.3 (EN)
unnamed: R24.1, U4.1 (~RST)
unnamed: R26.1, U2.18 (P3.7/INT3/TxD_2)
unnamed: R27.1, U2.17 (P3.6/ADC14/RxD_2)
SCL: JP2.3 (B), JP4.1 (A), U2.2 (P1.5/SCL/ADC5)
SDA: JP1.3 (B), JP3.1 (A), U2.1 (P1.4/SDA/ADC4)

Board: 2 copper layers, 71.6 x 27.5 mm, 61 parts (38 on the bottom side), 34 nets.

## KiCad design kicad/analog-switch/analog-switch/analog-switch.kicad_pcb

Parts:
J2, J5: Conn_01x20_Male; PinHeader_1x20_P2.54mm_Vertical
JP1: AnalogCom; PinHeader_1x02_P2.54mm_Vertical
Q1: Q_PNP_EBC; SOT-23
R1: 100K; R_0603_1608Metric
R2, R3: 1K; R_0603_1608Metric
U1, U3: CD74HC4067M; SSOP-24_5.3x8.2mm_P0.65mm
U2: 74HC595; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+5V: J5.20, Q1.1 (E), R1.1, U1.24 (VCC), U2.10 (~SRCLR), U2.16 (VCC), U3.24 (VCC)
AN1: JP1.1 (A), U1.1 (COM)
AN2: J5.1, JP1.2 (B), U3.1 (COM)
Clk: J2.18, U2.11 (SRCLK)
ClkH: J5.19, U2.12 (RCLK)
Data: J2.17, U2.14 (SER)
DataH: J5.18, U2.9 (QH')
GND: J2.20, R3.1, U1.12 (GND), U2.8 (GND), U3.12 (GND)
unnamed: J2.1, U1.9 (I0)
unnamed: J2.2, U1.8 (I1)
unnamed: J2.3, U1.7 (I2)
unnamed: J2.4, U1.6 (I3)
unnamed: J2.5, U1.5 (I4)
unnamed: J2.6, U1.4 (I5)
unnamed: J2.7, U1.3 (I6)
unnamed: J2.8, U1.2 (I7)
unnamed: J2.9, U1.23 (I8)
unnamed: J2.10, U1.22 (I9)
unnamed: J2.11, U1.21 (I10)
unnamed: J2.12, U1.20 (I11)
unnamed: J2.13, U1.19 (I12)
unnamed: J2.14, U1.18 (I13)
unnamed: J2.15, U1.17 (I14)
unnamed: J2.16, U1.16 (I15)
unnamed: J5.2, U3.9 (I0)
unnamed: J5.3, U3.8 (I1)
unnamed: J5.4, U3.7 (I2)
unnamed: J5.5, U3.6 (I3)
unnamed: J5.6, U3.5 (I4)
unnamed: J5.7, U3.4 (I5)
unnamed: J5.8, U3.3 (I6)
unnamed: J5.9, U3.2 (I7)
unnamed: J5.10, U3.23 (I8)
unnamed: J5.11, U3.22 (I9)
unnamed: J5.12, U3.21 (I10)
unnamed: J5.13, U3.20 (I11)
unnamed: J5.14, U3.19 (I12)
unnamed: J5.15, U3.18 (I13)
unnamed: J5.16, U3.17 (I14)
unnamed: J5.17, U3.16 (I15)
unnamed: Q1.2 (B), R1.2, R2.2
unnamed: U1.10 (S0), U2.15 (QA)
unnamed: U1.11 (S1), U2.1 (QB)
unnamed: U1.13 (S3), U2.3 (QD)
unnamed: U1.14 (S2), U2.2 (QC)
unnamed: U2.4 (QE), U3.10 (S0)
unnamed: U2.5 (QF), U3.11 (S1)
unnamed: U2.6 (QG), U3.14 (S2)
unnamed: U2.7 (QH), U3.13 (S3)
/OE: J2.19, Q1.3 (C), R2.1, R3.2, U1.15 (~E), U2.13 (~OE), U3.15 (~E)

Board: 2 copper layers, 18.9 x 51.8 mm, 10 parts (1 on the bottom side), 50 nets.

## KiCad design kicad/stm32_RJ45_4x2/stc8a_RJ45_4x2.kicad_pcb

File kicad/stm32_RJ45_4x2/README.txt:

https://github.com/1technophile/OpenMQTTGateway
https://github.com/bbx10/nanohab
https://github.com/bbx10/RFM69/   =>DIO0 is nIRQ

Board: 2 copper layers, 66.0 x 69.0 mm, 51 parts (3 on the bottom side), 64 nets.

Parts:
C1, C4, C7, C8, C9, C12: 104; SM0603_Capa
C2, C3, C5, C6: 10P; SM0603_Capa
C10, C11: 100u; SMDHD/VF
D2, D3: LED; LED-0603
F1: FUSE; SM1812
IC1: STM32F10XRC; TQFP_64
J1: RJ45_4X2
JP1: BOOT0; JMP3
JP2: BOOT1; JMP3
JP3: UPSEL; PIN_ARRAY_3X1
JP4: UNSEL; PIN_ARRAY_3X1
R1: 1K; SM0603
R2, R3, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20: 10K; SM0603
R4, R5: 100; SM0603
R6, R7: 0; SM0603
R21: PROG; PIN_ARRAY_2X1
RP1, RP2: 4K7; r_cat16-4
RV1: ADDR; RV3x3
U1: LM78M05CT; MP1584Mod
U2: NCP1117ST33T3G; SOT223
U3: ESP8266-07
VQFP44: VAL**; VQFP44
X1: 32.768K; QMONTRE
X2: 8M; crystal-HC49/S

Connections:
+3.3V: C1.2, C4.2, C8.2, C9.2, C11.1, C12.2, IC1.1, IC1.13, IC1.19, IC1.32, IC1.48, IC1.64, J1.60, JP1.1, JP2.1, R1.2, R2.1, R3.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.2, RP1.5, RP1.6, RP1.7, RP1.8, RP2.5, RP2.6, RP2.7, RP2.8, RV1.3, U2.2, U3.8
+12V: F1.1, J1.13, J1.61, U1.1
/1WR0: IC1.44, J1.3
/1WR1: IC1.45, J1.19
/1WR2: IC1.20, J1.35
/1WR3: IC1.22, J1.51
/1WR4: IC1.21, J1.27
/1WR5: IC1.23, J1.43
/5V: C10.1, J1.6, J1.14, J1.22, J1.30, J1.38, J1.46, J1.54, J1.62, U1.3, U2.3
/12V: F1.2, J1.5, J1.21, J1.29, J1.37, J1.45, J1.53
/ADC0: IC1.8, J1.1
/ADC1: IC1.9, J1.17
/ADC2: IC1.10, J1.33
/ADC3: IC1.11, J1.49
/ADC4: IC1.24, J1.25
/ADC5: IC1.25, J1.41
/ESPRX: JP3.3, R4.2, RP2.1, U3.15
/ESPTX: JP4.3, R5.2, RP2.2, U3.16
/IRM0: IC1.39, J1.2
/IRM1: IC1.40, J1.18
/IRM2: IC1.51, J1.34
/IRM3: IC1.52, J1.50
/IRM4: IC1.53, J1.26
/IRM5: IC1.2, J1.42
/RCV0: IC1.55, J1.7, R8.2
/RCV1: IC1.56, J1.23, R14.2
/RCV2: IC1.61, J1.39, R9.2
/RCV3: IC1.62, J1.55, R15.2
/RCV4: IC1.37, J1.31, R10.2
/RCV5: IC1.38, J1.47, R16.2
/RX1: IC1.43, J1.10, RP1.3
/SCL: IC1.58, J1.63, JP3.1, R7.2, RP2.4
/SDA: IC1.59, J1.59, JP4.1, R6.2, RP2.3
/SND0: IC1.29, J1.4, R11.2
/SND1: IC1.30, J1.20, R17.2
/SND2: IC1.33, J1.36, R12.2
/SND3: IC1.34, J1.52, R18.2
/SND4: IC1.35, J1.28, R13.2
/SND5: IC1.36, J1.44, R19.2
/SWCLK: IC1.49, J1.57, RP1.1
/SWDIO: IC1.46, J1.58, RP1.2
/TX1: IC1.42, J1.9, RP1.4
DGND: C1.1, C2.2, C3.1, C4.1, C5.2, C6.1, C7.1, C8.1, C9.1, C10.2, C11.2, C12.1, IC1.12, IC1.18, IC1.31, IC1.47, IC1.63, J1.8, J1.16, J1.24, J1.32, J1.40, J1.48, J1.56, J1.64, J1.65, JP1.3, JP2.3, R21.1, RV1.1, U1.2, U2.1, U3.9
unnamed: R7.1, U3.13
unnamed: IC1.17, R5.1
unnamed: IC1.16, R4.1
unnamed: R6.1, U3.14
unnamed: R20.1, U3.3
unnamed: IC1.41, U3.1
unnamed: IC1.15, RV1.2, U3.2
unnamed: R21.2, U3.12
unnamed: D2.2, IC1.27
unnamed: D3.2, IC1.26
unnamed: IC1.60, JP1.2
unnamed: J1.15, JP3.2
unnamed: J1.11, JP4.2
unnamed: C2.1, IC1.3, X1.1
unnamed: D3.1, R3.2
unnamed: C7.2, IC1.7, R1.1
unnamed: IC1.28, JP2.2
unnamed: C5.1, IC1.5, X2.1
unnamed: C6.2, IC1.6, X2.2
unnamed: C3.2, IC1.4, X1.2
unnamed: D2.1, R2.2

## KiCad design kicad/stm32_RJ45_4x2/sensorend.kicad_pcb

Parts:
C1, C2: 100u
C3: 10u
D1: LED
IC1: REG1117; burr-brown-SOT223
J1, J2: RJ45
JP1, JP3: DBG
JP2: PROG
JP4: 5VIN
K1: DS18B20
K2: HX1838
M1: RFM69HCW_95
P1: SI4432
P2: IRMOTION
Q1, Q2: S8550
R1, R2: 0
R3, R14: 100
R4, R5, R9, R11, R12, R15: 10K
R6: LUMIN
R7, R10, R13: 1K
R8, R16, R17: 4K7
U1: LM78M05CT; TO-220
U2: ESP8266-07
U3: NRF24L01-M

Connections:
+3.3V: C3.1, IC1.2 (VOUT), IC1.4 (VOUT), M1.13 (3V3), P1.5 (VDD), R4.2, R5.2, R6.1, R8.2, R15.1, R17.2, U2.8 (VCC), U3.2
+5V: C2.1, IC1.3 (VIN), JP4.2, K1.3, K2.3, R9.2, R11.2, R12.2, R14.2
+12V: C1.1, J1.5, J2.5, P2.1, U1.1 (IN)
/1WR: K1.2 (PM), R1.2, R9.1
/5VIN: J2.6, JP4.3, U1.3 (OUT)
/ADC: JP1.1, R6.2, R7.2, U2.2 (ADC)
/IRM: J2.3, JP3.1, P2.3, U2.4 (IO16)
/MISO: M1.2 (MISO), P1.6 (SDO), U2.6 (IO12), U3.7
/MOSI: M1.3 (MOSI), P1.7 (SDI), U2.7 (IO13), U3.6
/RCV: J2.7, R3.2, R10.1, U2.14 (IO5)
/RXD: J2.2, JP3.3, R4.1, U2.15 (RXD0)
/SCLK: M1.4 (SCK), P1.8 (SCLK), U2.5 (IO14), U3.5
/SDN: J2.4, P1.11 (SDN), R2.2, R13.1, U2.13 (IO4), U3.3
/TXD: J2.1, JP1.3, R5.1, U2.16 (TXD0)
DGND: C1.2, C2.2, C3.2, D1.2 (K), IC1.1 (GND), J1.8, J2.8, JP2.1, K1.1, K2.2 (PM), M1.1 (GND), M1.8 (GND), M1.10 (GND), P1.1 (GND), P1.12 (GND), P2.4, Q2.3 (C), R7.1, R16.1, U1.2 (GND), U2.9 (GND), U3.1
unnamed: J1.6, JP4.1
unnamed: J1.7, R3.1
unnamed: J1.1, JP1.2
unnamed: J1.2, JP3.2
unnamed: P2.2, R15.2
unnamed: Q1.1 (E), R14.1
unnamed: K2.1, R10.2, R11.1
unnamed: JP2.2, U2.12 (IO0)
unnamed: D1.1 (A), Q1.3 (C)
unnamed: Q2.1 (E), R17.1, U3.4
unnamed: M1.5 (NSS), P1.9 (nSEL), Q2.2 (B), R16.2, U2.10 (IO15)
unnamed: M1.14 (IO0), P1.10 (nIRQ), U2.11 (IO2), U3.8
unnamed: R8.1, U2.3 (EN)
unnamed: Q1.2 (B), R12.1, R13.2
unnamed: J1.4, R2.1
unnamed: J1.3, R1.1

Notes on the sheet:
LEFT
RIGHT

Board: 2 copper layers, 50.0 x 50.0 mm, 38 parts (8 on the bottom side), 31 nets.
